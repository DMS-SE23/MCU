# IAR project Adv-DMS-SE23-MCU-BL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: CMSIS\Device\ST\STM32F30x\Include; STM32F30x_StdPeriph_Driver\inc; Loader\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adv-DMS-SE23-MCU-BL.bin
  ILINK.IlinkOutputFile: Adv-DMS-SE23-MCU-BL.out
  ILINK.IlinkIcfFile: Loader\BOOT\stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCOptLevel: 3
  group DEVICE
    CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
    CMSIS/Device/ST/STM32F30x/Include/: stm32f30x.h system_stm32f30x.h
    CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group INC
    Loader/Inc/: cmd_handle.h common.h config.h gpio_control.h hook_tasks.h i2c_slave.h includes.h stm32_it.h
  group SRC
    Loader/Src/: cmd_handle.c gpio_control.c hook_tasks.c i2c_slave.c main.c stm32_it.c
  group STD_LIB
    STM32F30x_StdPeriph_Driver/src/: stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_rcc.c
  group WORKNOTE
    Loader/Worknote/: WORKNOTE.txt
