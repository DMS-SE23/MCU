<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Adv-DMS-SE23-MCU.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Adv-DMS-SE23-MCU-BL.ewp</path>
  </project>
  <batchBuild/>
</workspace>


