# IAR project Adv-DMS-SE23-MCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: Inc; CMSIS\Device\ST\STM32F30x\Include; CMSIS\Include; STM32F30x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Adv-DMS-SE23-MCU.srec
  ILINK.IlinkOutputFile: Adv-DMS-SE23-MCU.out
  ILINK.IlinkIcfFile: BOOT\stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group DEVICE
    CMSIS/Device/ST/STM32F30x/Source/Templates/iar/: startup_stm32f30x.s
    CMSIS/Device/ST/STM32F30x/Include/: stm32f30x.h system_stm32f30x.h
    CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group INC
    Inc/: adc_channel.h adv7186_control.h at_command.h battery_info.h dac_channel.h debug_port.h eeprom_control.h gpio_control.h hook_tasks.h hotkey_control.h i2c_master.h i2c_slave.h main.h odometer_control.h platform_config.h project.h protocol.h pwm_control.h rtc_control.h stm32_it.h vpm_control.h watchdog.h
  group INCLUDE
    STM32F30x_StdPeriph_Driver/inc/: stm32f30x_adc.h stm32f30x_can.h stm32f30x_comp.h stm32f30x_crc.h stm32f30x_dac.h stm32f30x_dbgmcu.h stm32f30x_dma.h stm32f30x_exti.h stm32f30x_flash.h stm32f30x_fmc.h stm32f30x_gpio.h stm32f30x_hrtim.h stm32f30x_i2c.h stm32f30x_iwdg.h stm32f30x_misc.h stm32f30x_opamp.h stm32f30x_pwr.h stm32f30x_rcc.h stm32f30x_rtc.h stm32f30x_spi.h stm32f30x_syscfg.h stm32f30x_tim.h stm32f30x_usart.h stm32f30x_wwdg.h
  group SRC
    Src/: adc_channel.c adv7186_control.c at_command.c battery_info.c dac_channel.c debug_port.c eeprom_control.c gpio_control.c hook_tasks.c hotkey_control.c i2c_master.c i2c_slave.c main.c odometer_control.c protocol.c pwm_control.c rtc_control.c stm32_it.c vpm_control.c watchdog.c
  group STD_LIB
    STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group WORKNOTE
    Worknote/: WORKNOTE-V00-01.txt
